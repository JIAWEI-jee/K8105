# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89F3531 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: K8105_hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hardware\DELAY;..\hardware\ADC;..\hardware\Flash;..\hardware\Uart;..\hardware\Key;..\hardware\Pwm;..\hardware\WDT;..\hardware\Timer;..\hardware\LCDdisplay;..\hardware\PID;..\hardware\TUYA
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
  group hardware
    ../hardware/DELAY/: delay.c
    ../hardware/ADC/: adc.c
    ../hardware/Flash/: flash.c
    ../hardware/Uart/: uart.c
    ../hardware/Key/: key.c
    ../hardware/Pwm/: pwm.c
    ../hardware/WDT/: wdt.c
    ../hardware/Timer/: timer.c
    ../hardware/LCDdisplay/: lcddisplay.c
    ../hardware/PID/: PID.c
  group TUYA
    ../hardware/TUYA/: mcu_api.c protocol.c system.c
